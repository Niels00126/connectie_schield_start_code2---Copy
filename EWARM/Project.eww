<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\connectie_schield_start_code2.ewp</path>
  </project>
  <batchBuild />
</workspace>
